# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: test
  AfterMake: D:\Keil5\ARM\ARMCC\bin\fromelf -cvf --vhx --32x1 -o ../Obj/test.hex ../Obj/test.axf
  AfterMake: D:\Keil5\ARM\ARMCC\bin\fromelf --bin -o ../Obj/test.bin ../Obj/test.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\CMSIS;..\Lib\inc;..\sys\delay;..\sys\sys;..\User;..\User\gpio;..\User\spi;..\User\timer;..\User\uart;..\User\w5500;..\User\dht11;..\User\timer
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x2000 size 0x2000
  group startup
    ../CMSIS/startup/: start.s
  group Lib
    ../Lib/src/: misc.c cm0_gpio.c cm0_uart.c
  group Sys
    ../sys/delay/: delay.c
    ../sys/sys/: sys.c
  group User
    ../User/: cm0_it.c main.c
    ../User/uart/: uart.c
    ../User/w5500/: W5500.c
    ../User/dht11/: dht11.c
